# Keil uVision project MasterChess_U2.uvprojx, settings and files
target Debug (6160000::V6.16::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MasterChess_U2 +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: HSE_VALUE=8000000
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ./src/: main.c
  group adc
    ./src/adc/: adc.c adc.h
  group config
    ./src/config/: Paths.h
  group irq
    ./src/irq/: stm32f4xx_it.c stm32f4xx_it.h
  group nfc
    ./src/nfc/: rc522.c rc522.h
  group distancia
    ./src/distancia/VL6180X/: thDistancia.c thDistancia.h vl6180x_api.c vl6180x_api.h vl6180x_cfg.h vl6180x_def.h vl6180x_i2c.c vl6180x_i2c.h vl6180x_platform.h vl6180x_types.h
  group com_placas
    ./src/com_placas/: ComunicacionPlacas.c ComunicacionPlacas.h
  group bajo_consumo
    ./src/bajo_consumo/: BajoConsumo.c BajoConsumo.h
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, CMSIS Driver:USART 2.13, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:ADC 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
